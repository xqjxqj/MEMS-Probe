# Keil uVision project MEMS_Probe_hw02_V0.2.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HT_Probe_0_2
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Users;.\Users\Driver;.\Users\Driver\RV-3029-C2;.\Users\USB;.\USB_Device\App;.\USB_Device\Target;.\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;;.\Users\qbus
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x17900
  memory RVCT10: RAM 0x10000000 size 0x8000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32G474VETx/STCubeGenerated/Src/: main.c stm32g4xx_it.c
    ./RTE/Device/STM32G474VETx/STCubeGenerated/Inc/: stm32g4xx_it.h
  group UsersApp
    ./Users/: CMDTask.c ringbuffer.c UserApp.c DataProcess.c IIR_filter.c UserStorage.c AttitudeSolve.c WellLineSensor.c
    ./Users/qbus/: mwd_interface.c qbus.c
  group UserDiver
    ./Users/Driver/: user_usart.c user_rtc.c fsmc_nand.c AD8557.c ADS8345.c
    ./Users/Driver/RV-3029-C2/: RV-3029-C2.c
    ./Users/USB/: USBD_STM32G4xx.c USBD_User_MSC_0.c
software components: CMSIS Driver:USB Device:Custom 1.0.0, CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:File 1.2.0, Compiler:I/O:STDOUT 1.2.0, File System:CORE 6.15.0, File System:Drive:NAND 6.15.0, USB:CORE 6.16.0, USB:Device 6.16.0, USB:Device:MSC 6.16.0, Device:STM32Cube HAL 1.4.0, CMSIS Driver:NAND:Memory Bus 1.1.0
