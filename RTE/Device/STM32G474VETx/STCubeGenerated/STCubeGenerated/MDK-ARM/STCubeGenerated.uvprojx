# Keil uVision project STCubeGenerated.uvprojx, settings and files
target STCubeGenerated (ARM-ADS)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STCubeGenerated +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../../Core/Inc;../../Drivers/STM32G4xx_HAL_Driver/Inc;../../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_ll_fmc.c stm32g4xx_hal_nand.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c
  group Drivers/CMSIS
    ../../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
